# Keil uVision project freertos.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: MDR1986BE93 Milandr
  pack: Keil.MDR1986BExx.1.4
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: testFrm1
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\Libs\CMSIS\CM3\CoreSupport;.\Libs\CMSIS\CM3\DeviceSupport\MDR32F9Qx\inc;.\Libs\CMSIS\CM3\DeviceSupport\MDR32F9Qx\startup\arm;.\Libs\MDR32F9Qx_StdPeriph_Driver\inc;.\Libs;.\Libs\FreeRTOS\include
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group StartUp
    ./Libs/CMSIS/CM3/DeviceSupport/MDR32F9Qx/startup/arm/: startup_MDR32F9Qx.s system_MDR32F9Qx.c
  group Project
    ./: main.c
  group FreeRTOS
    ./Libs/FreeRTOS/: croutine.c event_groups.c list.c port.c queue.c timers.c tasks.c heap_2.c
  group Libs
    ./Libs/MDR32F9Qx_StdPeriph_Driver/src/: MDR32F9Qx_rst_clk.c MDR32F9Qx_port.c MDR32F9Qx_can.c
